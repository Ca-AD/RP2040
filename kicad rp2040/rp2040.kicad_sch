File: kicad rp2040/rp2040.kicad_sch (KiCad schematic)
At the start: 35 parts

Commit message: 添加图片
Parts:
- gave numbers to parts that had none: 33
